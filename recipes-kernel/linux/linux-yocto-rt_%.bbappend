require const-linux-yocto.inc
