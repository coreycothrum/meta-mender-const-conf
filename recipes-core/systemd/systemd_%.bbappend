PACKAGECONFIG_append += "networkd resolved hostnamed"
